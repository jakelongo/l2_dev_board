File: l2_dev_alternative _nopwrsense/l2_dev_board.sch (KiCad schematic (older format))
At the start: 92 parts, among them P101 CONN_30, P102 CONN_30, P103 CONN_30, P104 CONN_30, P105 CONN_30, P106 CONN_30, P107 CONN_30, P108 CONN_30, P109 CONN_30, P110 CONN_30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

Commit message: doing the l2s alone
Parts:
- removed C109: 0.1uF, symbol C
- removed R114, R116: 10R, symbol R
- removed R115: 0.05, symbol R
- removed R118, R119, R120: 10k, symbol R
- removed R130: 33R, symbol R
- removed R131, R132, R133, R134, R135, R136: 1k, symbol R
- removed U112, U113, U114, U115: SN74LVC1G18, symbol SN74LVC1G18
- removed U121, U122, U124, U129, U130: NC7WZ17, symbol NC7WZ17
- removed U132: INA219, symbol INA219
- removed U133, U134: NB3N551, symbol NB3N551
- added U112, U113, U114, U115: NC7WZ17, symbol NC7WZ17
Connections:
- net labels removed: +3V3_L2, +3V3_L2_F, I2C_SCL, I2C_SDA, I2C_SDA_0, I2C_SDA_1, I2C_SDA_2, I2C_SDA_3, L1_CLK_20M, L1_DEBUG_N, L1_DEBUG_N_BUF, L1_DEBUG_N_BUF_B, L1_DEBUG_N_BUF_R, L1_DEBUG_N_L, L1_DEBUG_N_T, L1_MSEL_N, L1_RST_N, L1_RST_N_BUF_B, L1_RST_N_BUF_R, L1_RST_N_L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
- wire segments 1131 -> 973
- no-connect marks 4 -> 2
Other:
- note removed: "Current Measurment\n"
- note removed: "I2C Bus Pull-ups"
- note removed: "L1 MODULE"
- note removed: "L1 TDI/TDO SELECTORS"
- note removed: "More Buffering!"
- moved on the sheet: C101, C102, C103, C104, C105, C106, C107, C108, D101, L101, L102, R101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

Commit message: +1V0 power islands ready
Connections:
- net labels added: +1V0_B, +1V0_MB, +1V0_MT, +1V0_T
- wire segments 973 -> 985
Other:
- note added: "Nasty workaround for power\nsupplies layout\nwithout power sensing"

Commit message: logic error! remove the mux and put SW_4 instead
Other:
- note added: "TL- POS = 1\nML- POS = 8\nBL- POS = C\nMI- POS = 5\nRI- POS = 7"
- note removed: "TL- POS = 1\nML- POS = 8\nBL- POS = 5\nMI- POS = C\nRI- POS = 7"
Changed lines of the file:
@@
-EESchema Schematic File Version 2  date 01/09/2011 14:48:10
+EESchema Schematic File Version 2  date 01/09/2011 16:24:27
 LIBS:power
 LIBS:device
@@
 $EndComp
 Text Label 14470 14550 1    39   ~ 0
-TDI_T
+TDI_B
 Text Label 14270 14550 1    39   ~ 0
-TDO_T
+TDO_B
 $Comp
 L GND #PWR022
@@
 +3V3_PG
 Text Notes 6150 11570 0    30   ~ 0
-TL- POS = 1\nML- POS = 8\nBL- POS = 5\nMI- POS = C\nRI- POS = 7
+TL- POS = 1\nML- POS = 8\nBL- POS = C\nMI- POS = 5\nRI- POS = 7
 Text Notes 6590 10480 0    60   ~ 0
 JTAG SWITCH BOARD CONFIG

Commit message: added buffers for most of the signals now. almost done
Parts:
- removed U102: NC7SZ157, symbol NC7SZ157
Connections:
- wire segments 985 -> 980
Changed lines of the file:
@@
-EESchema Schematic File Version 2  date 01/09/2011 16:24:27
+EESchema Schematic File Version 2  date 01/09/2011 16:28:35
 LIBS:power
 LIBS:device
@@
 Comment4 ""
 $EndDescr
+Text Label 2750 6250 2    39   ~ 0
+SWT_4
 Wire Wire Line
 	18460 12250 18580 12250
@@
 Wire Wire Line
 	4740 1080 4740 1120
-Wire Wire Line
-	1650 6470 1650 6520
-Wire Wire Line
-	1650 6010 1650 6040
 Wire Notes Line
 	5970 8740 1280 8740
 Wire Wire Line
-	2200 5700 2200 5640
-Wire Wire Line
 	3720 6180 3720 6140
 Wire Notes Line
@@
 Connection ~ 3190 6250
 Wire Wire Line
-	1590 6160 1650 6160
-Wire Wire Line
-	1590 6340 1650 6340
-Wire Wire Line
 	6190 10860 6050 10860
 Wire Wire Line
@@
 Text Label 4740 1080 2    39   ~ 0
 SWT_1
-Text Label 1590 6340 2    39   ~ 0
-SWT_3
-Text Label 1590 6160 2    39   ~ 0
-SWT_2
-$Comp
-L GND #PWR0101
-U 1 1 4E38244E
-P 1650 6520
-F 0 "#PWR0101" H 1650 6520 30  0001 C CNN
-F 1 "GND" H 1650 6450 30  0001 C CNN
-	1    1650 6520
-	1    0    0    -1
-$EndComp
-Text Label 2200 5640 2    39   ~ 0
-SWT_1
-$Comp
-L +3.3V #PWR0102
-U 1 1 4E382389
-P 1650 6010
-F 0 "#PWR0102" H 1650 5970 30  0001 C CNN
-F 1 "+3.3V" H 1650 6120 30  0000 C CNN
-	1    1650 6010
-	1    0    0    -1
-$EndComp
-$Comp
-L NC7SZ157 U102
-U 1 1 4E38237C
-P 2200 6250
-F 0 "U102" H 2000 6540 60  0000 C CNN
-F 1 "NC7SZ157" H 2180 5950 60  0000 C CNN
-	1    2200 6250
-	1    0    0    -1
-$EndComp
 $Comp
 L GND #PWR0103

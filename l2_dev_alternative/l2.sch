File: l2_dev_alternative/l2.sch (KiCad schematic (older format))
At the start: 13 parts, among them U301 XS1_L2-QFN124

Commit message: buffers are in and BOM started. Changed open drain buffers for normal buffers and added pull ups to the _N JTAG signals

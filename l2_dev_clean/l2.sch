File: l2_dev_clean/l2.sch (KiCad schematic (older format))
At the start: 13 parts, among them U301 XS1_L2-QFN124

Commit message: If you don't want power sensing you can make the board smaller! added the JTAG signals with buffers

Commit message: added extra buffers to remove lengthy lines. Also looking and audio board for L1 layout!
